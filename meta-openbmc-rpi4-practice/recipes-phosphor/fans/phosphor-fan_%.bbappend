# Allow sensor threshold events without host power-state checks.
EXTRA_OEMESON:append = " -Dskip-power-checking=enabled"
