# Expose Phosphor Logging D-Bus entries through Redfish EventLog.
PACKAGECONFIG:append = " redfish-dbus-log"
